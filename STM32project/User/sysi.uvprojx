# Keil uVision project sysi.uvprojx, settings and files
target sysi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sysi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\Core;..\HardWare\delay;..\HardWare\dian_ji;..\HardWare\infrared;..\HardWare\ZLG7289;..\User;..\Rcc;..\HardWare\led_key;..\HardWare\nvic;..\HardWare\USART;..\Application\move_base\inc;..\Application\navigation\inc;..\Application\process\inc;..\HardWare\Time;..\HardWare\stmflash
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/process/src
    ./: main.c system_stm32f10x.c
    ../Application/process/src/: process.c
  group Application/process/inc
    ../Application/process/inc/: process.h parameter.h
  group Application/mouse/src
    ../Application/process/src/: mouseApp.c mouseFuncLib.c mapSaver.c comHandle.c
  group Application/mouse/inc
    ../Application/process/inc/: mouseApp.h mouseFuncLib.h mapSaver.h
  group Application/navigation/src
    ../Application/navigation/src/: NavigationMain.c Odometer.c OccupyingGrid.c ErgodicMap.c myPlanner.c navigator.c
  group Application/navigation/inc
    ../Application/navigation/inc/: NavigationMain.h Odometer.h OccupyingGrid.h ErgodicMap.h myPlanner.h navigator.h
  group Application/move_base/src
    ../Application/move_base/src/: MoveMain.c pidctrller.c InfraredCalc.c attitude.c MoveCtrl.c
  group Application/move_base/inc
    ../Application/move_base/inc/: MoveMain.h pidctrller.h InfraredCalc.h attitude.h MoveCtrl.h
  group Dirver_hw
    ../Core/: drive.c
    ../HardWare/delay/: delay.c
    ../HardWare/dian_ji/: dain_ji.c
    ../HardWare/infrared/: infrared.c
    ../HardWare/ZLG7289/: ZLG7289.c
    ../HardWare/led_key/: led.c
    ../HardWare/USART/: usart.c
    ../HardWare/Time/: time.c
    ../HardWare/stmflash/: stmflash.c
  group Driver_core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
